# IAR project project.ewp, settings and files
configuration RX (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003; RX
  ICCSTM8.CCIncludePath2: lib\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration TX (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCDefines: STM8S003; TX
  group (top)
    src/: rx.c tx.c
  group lib/inc
    lib/inc/: clock.h ibus.h radio.h radio_config_Si4463.h spi.h stm8s.h uart.h util.h
  group lib/src
    lib/src/: clock.c ibus.c radio.c spi.c uart.c util.c
